## conf/machine/raspberrypi3-custom.conf
```bitbake
#@TYPE: Machine
#@DESCRIPTION: Custom Machine configuration for raspberrypi3

require conf/machine/raspberrypi3.conf
```
